# Keil uVision project 320.uvprojx, settings and files
target LPC1114 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 320 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Listings;.\Objects;.\RTE\Device\LPC1114FBD48_301
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group user_code
    ./: main.c
  group up_drice
    ./: KEY.c MF58.c LED.c
  group low_drice
    ./: ADC.c UART.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
